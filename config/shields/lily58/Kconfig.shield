## config/shields/lily58/Kconfig.shield
```kconfig
config SHIELD_LILY58_LEFT
    bool "Lily58 Left"

config SHIELD_LILY58_RIGHT
    bool "Lily58 Right"
```
